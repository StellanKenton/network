# Keil uVision project network.uvprojx, settings and files
target NetWork (5060960::V5.06 update 7 (build 960)::.\ACC5)
  device: GD32F407VG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NetWork +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\ETHERNET;..\HARDWARE\TIMER;..\HARDWARE\LED;..\HARDWARE\SRAM;..\FWLIB\STM32F4x7_ETH_Driver\inc;..\MALLOC;..\LWIP;..\LWIP\arch;..\LWIP\lwip_header;..\LWIP\app\TCP_Client;..\LWIP\lwip_app\lwip_comm;..\LWIP\lwip-1.4.1\src\include;..\LWIP\lwip-1.4.1\src\include\ipv4;..\LWIP\lwip-1.4.1\src\include\lwip;..\LWIP\lwip-1.4.1\src\include\netif;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\UCOSII\COMPAT;..\mqtt\src;..\mqtt\transport;..\mqtt\app;..\HARDWARE\DS18B20;..\mqtt\hmac_sha1\hmac;..\mqtt\hmac_sha1\sha;..\mqtt\cjson;..\HARDWARE\U2GBK;..\TEXT;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\FATFS\exfuns;..\FATFS\src;..\HARDWARE\SDIO;..\app\bsp;..\app\port;..\rep\service\console;..\rep\service\rtos;..\rep\tools\ringbuffer
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c rep_config.h
  group APP-SYSTEM
    ../app/system/: system.c sysmgr.c systask.c
  group APP-MANAGER
    ../app/manager/iotmanager/: iotmanager.c iotmanager.h
    ../app/manager/wireless/: wireless.c wireless.h
    ../app/manager/cellular/: cellular.c cellular.h
    ../app/manager/ethernet/: ethernet.c ethernet.h
  group APP-BSP
    ../app/bsp/: bsp_rtt.c bsp_rtt.h
  group APP-PORT
    ../app/port/: log_port.c rtos_port.c rtos_port.h
  group APP-SEGGER
    ../app/SEGGER/: SEGGER_RTT.c
  group REP-SERVICE
    ../rep/service/console/: console.c log.c
    ../rep/service/rtos/: rtos.c
  group REP-TOOLS
    ../rep/tools/ringbuffer/: ringbuffer.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/ETHERNET/: LAN8720.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/U2GBK/: U2GBK.c
    ../TEXT/: text.c fontupd.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
  group CORE
    ../CORE/: core_cm4.h core_cm4_simd.h startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_fsmc.c stm32f4xx_spi.c stm32f4xx_sdio.c stm32f4xx_dma.c
    ../FWLIB/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group LWIP-APP
    ../LWIP/lwip_app/lwip_comm/: lwip_comm.c
  group LWIP-NETIF
    ../LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LWIP-CORE
    ../LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c mem.c
  group LWIP-ARCH
    ../LWIP/arch/: sys_arch.c
  group LWIP-API
    ../LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group UCOS3_CORE
    ../UCOSII/COMPAT/: os_cfg_app.c os_int.c os_msg.c os_pend_multi.c os_prio.c os_stat.c os_tick.c os_var.c
    ../UCOSII/CORE/: os_core.c os_flag.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../UCOSII/PORT/: os_dbg.c
  group UCOS3_PORT
    ../UCOSII/PORT/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group UCOS3_CPU_LIB
    ../UCOSII/COMPAT/: cpu_core.c lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group UCOS3_CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h os_cfg_app.h cpu_cfg.h lib_cfg.h
  group MALLOC
    ../MALLOC/: malloc.c
  group mqtt/app
    ../mqtt/app/: mqtt_app.c
  group mqtt/src
    ../mqtt/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group mqtt/transport
    ../mqtt/transport/: transport.c
  group mqtt/hmac_sha1
    ../mqtt/hmac_sha1/sha/: sha1.c
    ../mqtt/hmac_sha1/hmac/: hmac_sha1.c
  group mqtt/cjson
    ../mqtt/cjson/: cJSON.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
    ../FATFS/src/: diskio.c ff.c
