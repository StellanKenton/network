# Keil uVision project network.uvprojx, settings and files
target Network (5060960::V5.06 update 7 (build 960)::.\ACC5)
  device: GD32F407VG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: network +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_USED=1
  c include: .;..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\User;..\User\port;..\User\bsp\usbhost\inc;..\User\bsp\usbhost\official\host_inc;..\User\bsp\usbhost\official\otg_inc;..\HARDWARE\LED;..\rep\tools\ringbuffer;..\UCOSIII\uC-CPU;..\UCOSIII\uC-LIB;..\UCOSIII\uCOS-III;..\UCOSIII\UCOS_BSP;..\UCOSIII\uCOS_CONFIG;..\UCOSIII\uCOS-III\Source;..\UCOSIII\uC-CPU\ARM-Cortex-M4\RealView;..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
    ../User/system/: system_rtt.c system.c sysmgr.c system_storage.c systask.c
    ../User/manager/iotmanager/: iotmanager.c protcolmgr.c iotmanager_debug.c cprsensor_protocol.c
    ../User/manager/wireless/: wireless.c wireless_debug.c
    ../User/port/: esp32c5_port.c ec800m_port.c log_port.c drvgpio_port.c drvuart_port.c rtos_port.c drvspi_port.c drvusb_port.c w25qxxx_port.c fatfs_diskio.c
    ../User/manager/cellular/: cellular.c
    ../User/manager/ethernet/: ethernet.c
    ../User/bsp/: bsp_rtt.c bspgpio.c bspuart.c bspusb.c bspusb_ec800.c bspspi.c
    ../rep/driver/drvgpio/: drvgpio.c
    ../rep/driver/drvuart/: drvuart.c
    ../rep/driver/drvspi/: drvspi.c
    ../rep/driver/drvusb/: drvusb.c
    ../User/bsp/usbhost/src/: usbhost_ec800.c usbh_cdc_host.c
    ../User/bsp/usbhost/official/host_src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../User/bsp/usbhost/official/otg_src/: usb_core.c usb_hcd.c usb_hcd_int.c
    ../rep/comm/flowparser/: flowparser.c flowparser_stream.c
    ../rep/tools/ringbuffer/: ringbuffer.c
    ../rep/tools/md5/: md5.c
    ../rep/tools/aes/: aes.c
    ../rep/tools/jsonparser/: jsonparser.c
    ../rep/tools/trace/: trace.c
    ../rep/service/rtos/: rtos.c
    ../rep/service/log/: log.c console.c
    ../rep/service/vfs/: vfs.c vfs_littlefs.c vfs_fatfs.c vfs_debug.c
    ../rep/module/w25qxxx/: w25qxxx.c
    ../rep/module/esp32c5/: esp32c5.c esp32c5_ctrl.c esp32c5_ble.c esp32c5_wifi.c esp32c5_http.c esp32c5_mqtt.c esp32c5_data.c
    ../rep/module/ec800m/: ec800m.c ec800m_http.c ec800m_mqtt.c
    ../rep/lib/SEGGER/: SEGGER_RTT.c
    ../rep/lib/fatfs/: ff.c
    ../rep/lib/fatfs/option/: cc936.c
    ../rep/lib/littlefs/: lfs.c lfs_util.c
  group HARDWARE
    ../rep/module/sdcard/: sdcard.c
    ../User/port/: sdcard_port.c
    ../User/bsp/: bsp_sdio.c
    ../HARDWARE/LED/: led.c
  group CORE
    ../CORE/: core_cm4.h core_cm4_simd.h startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_dma.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_fsmc.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_sdio.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group UCOSIII_BSP
    ../UCOSIII/UCOS_BSP/: bsp.c
  group UCOSIII_CPU
    ../UCOSIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
    ../UCOSIII/uC-CPU/: cpu_core.c
  group UCOSIII_LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOSIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOSIII_CORE
    ../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_c.c os_cpu_a.asm
  group UCOSIII_CONFIG
    ../UCOSIII/uCOS_CONFIG/: app_cfg.h cpu_cfg.h lib_cfg.h includes.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
